# Keil uVision project Servo_ansteuerung.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Servo_ansteuerung
  c flags: Optimize=8 SizeSpeed=1
  link misc: nooverlay
  group Source Group 1
    ./: init.c main.c
