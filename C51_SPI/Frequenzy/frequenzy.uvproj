# Keil uVision project frequenzy.uvproj, settings and files
target frequenzy (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: frequenzy
  c flags: Optimize=9
  link misc: nooverlay
  group Source Group 1
    ./: LCD.c init.c mainsource.c SPI.c
